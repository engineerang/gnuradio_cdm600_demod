options:
  parameters:
    author: engineerang
    generate_options: qt_gui
    id: sa
    output_language: python
    title: Spectrum Analyzer
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '180000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: LNAL
    ant1: LNAL
    args: '"driver=lime,soapy=2,nchan=2"'
    bb_gain0: '0'
    bb_gain1: '0'
    bw0: samp_rate
    bw1: samp_rate
    corr1: '0'
    dc_offset_mode1: '0'
    freq0: freq
    freq1: freq
    gain0: '0'
    gain1: '0'
    gain_mode0: 'True'
    gain_mode1: 'True'
    if_gain0: '0'
    if_gain1: '0'
    iq_balance_mode1: '0'
    nchan: '2'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 0,0,1,1
    label1: Modem A -> Modem B
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"red"'
    fc: freq
    fftsize: '1024'
    gui_hint: 2,0,1,1
    label1: Modem B -> Modem A
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 0,1,1,1
    label1: Modem A -> Modem B
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 2,1,1,1
    label1: Modem B -> Modem A
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '1', qtgui_freq_sink_x_0_1, '0']
- [osmosdr_source_0, '1', qtgui_waterfall_sink_x_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0

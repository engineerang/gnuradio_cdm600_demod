options:
  parameters:
    author: engineerang
    generate_options: qt_gui
    id: cdm600_demod_qpsk
    output_language: python
    title: cdm600_demod_qpsk
  states: {}

blocks:
- name: arity
  id: variable
  parameters:
    value: '2'
  states: {}
- name: baudrate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '180000000'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: order
  id: variable
  parameters:
    value: '4'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, int(numpy.ceil(11*sps*nfilts)))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/baudrate
  states: {}
- name: timing_loop_bw
  id: variable_qtgui_range
  parameters:
    label: 'Time: BW'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.0628'
  states: {}
- name: timing_loop_bw_0
  id: variable_qtgui_range
  parameters:
    label: 'Time: BW sync'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.01'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[1,1j, -1,-1j]'
    precision: '8'
    sym_map: '[0, 1, 2, 3]'
    type: dqpsk
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: comtech_qpsk.bits
    type: byte
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '2'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '80'
    type: byte
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_0
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: order
    w: timing_loop_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: order
  states: {}
- name: digital_map_bb_1_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: '1'
    loop_bw: timing_loop_bw_0
    max_dev: '0.01'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: baudrate
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '50000'
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '1512'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    ant0: LNAL
    args: '"driver=lime,soapy=1,nchan=1"'
    bb_gain0: '0'
    bw0: samp_rate
    freq0: freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: byte
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,0,1,1
    name: ''
    size: '1024'
    type: complex
    update_time: '0.00010'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 0,0,1,1
    label1: Modem A -> Modem B
    nconnections: '2'
    type: complex
  states: {}
- name: satellites_descrambler308_0
  id: satellites_descrambler308
  parameters: {}
  states: {}
- name: satellites_hdlc_deframer_0
  id: satellites_hdlc_deframer
  parameters:
    check_fcs: 'True'
    max_length: '10000'
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [blocks_repack_bits_bb_0, '0', blocks_repack_bits_bb_0_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_repack_bits_bb_0_0, '0', satellites_descrambler308_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0_0_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', virtual_sink_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_1_0, '0']
- [digital_map_bb_1_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0_0, '0']
- [low_pass_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '1']
- [osmosdr_source_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [osmosdr_source_0_0, '0', satellites_rms_agc_0, '0']
- [pdu_pdu_to_stream_x_0, '0', blocks_file_sink_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, network_socket_pdu_0, pdus]
- [satellites_descrambler308_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [satellites_descrambler308_0, '0', satellites_hdlc_deframer_0, '0']
- [satellites_hdlc_deframer_0, out, network_socket_pdu_0, pdus]
- [satellites_hdlc_deframer_0, out, pdu_pdu_to_stream_x_0, pdus]
- [satellites_rms_agc_0, '0', low_pass_filter_0, '0']
- [virtual_source_0, '0', digital_constellation_decoder_cb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
